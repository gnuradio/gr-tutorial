<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>chat_app</value></param>
<param><key>title</key><value>MessagePassingChatApp</value></param>
<param><key>author</key><value>Martin Braun</value></param>
<param><key>description</key><value>A chat app that uses message passing</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>tutorial_chat_receiver</key>
<param><key>id</key><value>tutorial_chat_receiver_0</value></param>
</block>
<block>
<key>tutorial_chat_sanitizer</key>
<param><key>id</key><value>tutorial_chat_sanitizer_0</value></param>
<param><key>prefix</key><value>UserName</value></param>
<param><key>msg</key><value>msg_str</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>msg_str</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Hello World!</value></param>
</block>
<connection><source_block_id>tutorial_chat_sanitizer_0</source_block_id><sink_block_id>tutorial_chat_receiver_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
